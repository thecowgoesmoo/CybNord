/*
MIDI On/Off Messages
By Amanda Ghassaei
July 2012
https://www.instructables.com/id/Send-and-Receive-MIDI-with-Arduino/

 * This program is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation; either version 3 of the License, or
 * (at your option) any later version.

*/
 

byte i = 0;
byte val = 0; //0;

byte ctr = 0;

byte draws [9] = {0, 0, 0, 0, 0, 0, 0, 0, 0};
byte ccCh = 0;
byte ccVal = 0;
byte command = 176;
int r0 = 0;
int r1 = 0;
int r2 = 0;
int r3 = 0;

int s0 = 3;
int s1 = 4;
int s2 = 5;
int s3 = 6;
int en = 2;

void setup() {
  //  Set MIDI baud rate:
  Serial.begin(9600);
  pinMode(s0, OUTPUT);
  pinMode(s1, OUTPUT);
  pinMode(s2, OUTPUT);
  pinMode(s3, OUTPUT);
  pinMode(en, OUTPUT);
}

void loop() {
  delay(10);
  ctr = ctr+1;
  for (i=0; i<14; ++i) {
}
//digitalWrite(LED_BUILTIN, globalNoteOn);
for (i=0; i<9; ++i) {
  //val = analogRead(i);
  r0 = bitRead(i,0);
  r1 = bitRead(i,1);
  r2 = bitRead(i,2);
  r3 = bitRead(i,3);
  digitalWrite(s0, r0);
  digitalWrite(s1, r1);
  digitalWrite(s2, r2);
  digitalWrite(s3, r3);
  //Toggle the enable:
  digitalWrite(en, 0);
  delay(20);
  //digitalWrite(en, 1);
  analogRead(i);
  delay(20);
  //val = analogRead(i);
  val = analogRead(0);
  //digitalWrite(en, 1);
  val = val/2;///2;
  if (abs(val-draws[i])>12){
    draws[i] = val;
    ccCh = i + 16;
    MIDImessage(command,ccCh,val);
  } 
}
}

//send MIDI message
void MIDImessage(byte command, byte ccCh, byte ccVal) {
Serial.write(command);
Serial.write(ccCh);
Serial.write(ccVal);
//
//Serial.print(command);
//Serial.print(' ');
//Serial.print(ccCh);
//Serial.print(' ');
//Serial.println(ccVal);
//Serial.write(command);//send note on or note off command 
//Serial.write(MIDInote);//send pitch data
//Serial.write(MIDIvelocity);//send velocity data
//Serial.print("noteON, clock cycle: ");
//Serial.println(ctr);
}
